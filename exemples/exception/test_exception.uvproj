# Keil uVision project test_exception.uvproj, settings and files
target Simu (ARM-GNU)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: test_exception
  AfterMake: arm-none-eabi-size hello.elf
  group Code
    ./: b~hello.adb b~hello.ads hello.adb pac_exception.adb pac_exception.ads startup.S stm32f103.ld
  group Objs
    ./: b~hello.o hello.o pac_exception.o
  group C
    ./C/: lcd.c led_c.c
