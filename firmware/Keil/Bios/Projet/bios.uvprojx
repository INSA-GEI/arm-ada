# Keil uVision project bios.uvprojx, settings and files
target RVDS_Full (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm-ada-bios +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER USE_MCBSTM32F300 STM32F30X
  c include: ..\Libraries;..\Libraries\cmsis;..\Drivers;..\Applis;..\GUI;..\FatFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\bios.sct
  group Boot
    ../Boot/: system_stm32f30x.c startup_rvds.s
  group Drivers
    ../Drivers/: GLCD_8Bits_STM32.c keys.c usart.c
  group Applis
    ../Applis/: version.h reprog.c retarget.c bios.c
    ./: Flash_Routines.s
  group Libs
    ../Libraries/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group GUI
    ../GUI/: ProgressBar.c
software components: CMSIS:CORE 5.0.0
