# Keil uVision project simple.uvproj, settings and files
target Simple (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: simple
  c flags: Optim=1
  c include: ..\Shared
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Boot
    ../Shared/: startup.s
  group Appli
    ./: main.c
    ../Shared/: api.c
