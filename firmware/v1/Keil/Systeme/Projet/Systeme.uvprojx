# Keil uVision project Systeme.uvprojx, settings and files
target GCC (ARM-GNU)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader-ada
  AfterMake: arm-none-eabi-size objs/bootloader-ada.elf
  group Boot
    ../Boot/: system_stm32f30x.c startup_rvds.s
    ./: arm-ada-os.sct
  group Drivers
    ../Drivers/: GLCD_8Bits_STM32.c keys.c potentiometers.c rng.c audio.c sram.c sd_spi_drv.c stm32303c_eval_spi_sd.c l3gd20.c lsm303dlhc.c usart.c led.c console.c m_alloc.c timer.c
  group ABI
    ../Applis/: ABI.h ABI_Table.c ABI_Table_Ptr.s
  group Applis
    ../Applis/: version.h unpackbmp.c system.c reprog.c tests.c retarget.c panic.c
  group Ressources
    ../Ressources/: ressources.c
  group Libs
    ../Libraries/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group GUI
    ../GUI/: ProgressBar.c Window.c
  group FatFS
    ../FatFS/src/: diskio.c ff.c
  group AudioSynth
    ../AudioSynth/: AudioSynth.c
target RVDS (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader-ada
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER USE_MCBSTM32F300 STM32F30X
  c include: ..\Libraries\CMSIS;..\Libraries;..\Drivers;..\Applis;..\GUI;..\FatFS\src
  asm misc: --list=
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
target RVDS_Full (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: as above
  output: arm-ada-os +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER USE_MCBSTM32F300 STM32F30X
  c include: ..\Libraries;..\Libraries\cmsis;..\Drivers;..\Applis;..\GUI;..\FatFS\src;..\Ressources;..\AudioSynth
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\arm-ada-os.sct
software components: CMSIS:CORE 4.3.0
